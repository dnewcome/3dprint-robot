Commit message: assembly: re-place j5 for the lifted angle_drive plate

File: sim/arm_trunk.urdf (robot description, URDF)
Before this commit: robot micro_arm, 7 links, 6 joints
Joints:
- joint j5_tool_roll: origin xyz=0.0270 -0.0090 0.0000 -> xyz=0.0285 -0.0487 0.0000
